# IAR project GestionDeTransport.ewp, settings and files
configuration GestionDeTransport (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GestionDeTransport.hex
  ILINK.IlinkOutputFile: GestionDeTransport.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Interfaces
    ../Src/: interfaceS0002.c interfaceS0002.h interfaceT1.c interfaceT1.h interfaceT2.c interfaceT2.h
  group Application/User/Pilotes
    ../Src/: piloteCAN1.c piloteCAN1.h piloteIOT1.c piloteIOT1.h piloteIOT2.c piloteIOT2.h piloteTimer6Up.c piloteTimer6Up.h piloteUSART2.c piloteUSART2.h
  group Application/User/Processus
    ../Src/: processusAscenseur.c processusAscenseur.h ProcessusCAN_UART.c processusCAN_UART.h processusClignotant.c processusClignotant.h processusReceptionEtat.h
  group Application/User/Services
    ../Src/: serviceBaseDeTemps.c serviceBaseDeTemps.h ServiceCAN637.c ServiceCAN637.h serviceProtocole637.c serviceProtocole637.h serviceTriac.c serviceTriac.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
